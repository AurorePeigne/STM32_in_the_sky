# IAR project Project-B-L475E-IOT01.ewp, settings and files
configuration Project-B-L475E-IOT01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; USE_STM32L4XX_NUCLEO; USE_B_L475E_IOT01; ASSISTED_GNSS; USE_FREE_RTOS; MBEDTLS_CONFIG_FILE=<httpclient_mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_DEBUG; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; USE_MBED_TLS; HTTPCLIENT; USE_WIFI; USE_CLEAR_TIMEDATE
  ICCARM.CCIncludePath2: ../../Inc; ../../Common/Shared/Inc; ../../Common/httpclient/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/B-L475E-IOT01; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/TeseoIII; ../../../../../../Drivers/BSP/Components/es_wifi; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1; ../../../../../../Middlewares/ST/STM32_GNSS/LibAGNSS/Inc; ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Inc; ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Inc; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/cJSON; ../../../../../../Middlewares/Third_Party/MbedTLS/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Inc
  OBJCOPY.OOCOutputFile: Project-B-L475E-IOT01.bin
  ILINK.IlinkOutputFile: Project-B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Common
    ../../Common/Shared/Src/: cloud.c entropy_hardware_poll.c heap.c http_lib.c iot_flash_config.c mbedtls_net.c net.c net_tcp_wifi.c net_tls_mbedtls.c STM32CubeRTCInterface.c timedate.c timingSystem.c wifi_net.c
    ../../Src/: flash_l4.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/httpclient
    ../../Common/httpclient/Src/: httpclient.c
  group Application/User
    ../../Src/: a_gnss.c config_bus.c gnss_if.c gnss_utils.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/WiFi
    ../../Src/: es_wifi_io.c wifi.c
  group Drivers/BSP/B-L475E-IOT1
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/TeseoIII
    ../../../../../../Drivers/BSP/Components/TeseoIII/: teseo_i2c.c teseo_io.c teseo_queue.c teseo_uart.c
  group Drivers/BSP/X-NUCLEO-GNSS1A1
    ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1/: gnss_fw_upgrade.c x_nucleo_gnss1a1.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Middlewares/ST/STM32_GNSS/LibAGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibAGNSS/Lib/: libAGNSS_IAR7.a
  group Middlewares/ST/STM32_GNSS/LibGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Src/: gnss_data.c gnss_parser.c
  group Middlewares/ST/STM32_GNSS/LibNMEA
    ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Src/: NMEA_parser.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
