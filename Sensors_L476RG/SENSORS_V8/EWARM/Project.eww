<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\V1_test_ADC2Channels.ewp</path>
  </project>
  <batchBuild />
</workspace>
