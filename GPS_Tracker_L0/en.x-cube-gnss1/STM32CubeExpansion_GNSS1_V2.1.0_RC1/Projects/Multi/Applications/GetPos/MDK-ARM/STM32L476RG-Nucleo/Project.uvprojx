# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,USE_FREE_RTOS
  c misc: --C99 --gnu
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\TeseoIII;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-GNSS1A1;..\..\..\..\..\..\Middlewares\ST\STM32_GNSS\LibGNSS\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_GNSS\LibNMEA\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c gnss_utils.c config_bus.c gnss_if.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/BSP/Components/TeseoIII
    ../../../../../../Drivers/BSP/Components/TeseoIII/: teseo_i2c.c teseo_io.c teseo_queue.c teseo_uart.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-GNSS1A1
    ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1/: x_nucleo_gnss1a1.c gnss_fw_upgrade.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/ST/STM32_GNSS/LibNMEA
    ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Src/: nmea_parser.c
  group Middlewares/ST/STM32_GNSS/LibGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Src/: gnss_parser.c gnss_data.c
software components: CMSIS:CORE 5.0.2
