# Keil uVision project Project.uvprojx, settings and files
target Project-B-L475E-IOT01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project-B-L475E-IOT01
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,USE_STM32L4XX_NUCLEO,USE_B_L475E_IOT01,ASSISTED_GNSS,USE_FREE_RTOS,MBEDTLS_CONFIG_FILE=<httpclient_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_DEBUG,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,HTTPCLIENT,USE_WIFI,USE_CLEAR_TIMEDATE
  c misc: --gnu
  c include: ../../Inc;../../Common/Shared/Inc;../../Common/httpclient/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/TeseoIII;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1;../../../../../../Middlewares/ST/STM32_GNSS/LibAGNSS/Inc;../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Inc;../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Middlewares/Third_Party/MbedTLS/include
  asm include: ../../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dac.c stm32l4xx_hal_rng.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_hash.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_crc.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_flash.c stm32l4xx_hal.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_nor.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_spi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_uart.c stm32l4xx_hal_sram.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_flash_ex.c
  group Application/httpclient
    ../../Common/httpclient/Src/: httpclient.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/TeseoIII
    ../../../../../../Drivers/BSP/Components/TeseoIII/: teseo_queue.c teseo_uart.c teseo_i2c.c teseo_io.c
  group Middlewares/ST/STM32_GNSS/LibAGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibAGNSS/Lib/: libAGNSS_IAR7.a
  group Application/User
    ../../Src/: gnss_utils.c a_gnss.c config_bus.c stm32l4xx_hal_msp.c gnss_if.c main.c stm32l4xx_it.c
  group Middlewares/ST/STM32_GNSS/LibGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Src/: gnss_data.c gnss_parser.c
  group Application/Common
    ../../Common/Shared/Src/: timedate.c net.c iot_flash_config.c http_lib.c entropy_hardware_poll.c timingSystem.c mbedtls_net.c net_tcp_wifi.c heap.c STM32CubeRTCInterface.c cloud.c wifi_net.c net_tls_mbedtls.c
    ../../Src/: flash_l4.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c timers.c queue.c tasks.c list.c event_groups.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/X-NUCLEO-GNSS1A1
    ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1/: gnss_fw_upgrade.c x_nucleo_gnss1a1.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Middlewares/ST/STM32_GNSS/LibNMEA
    ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Src/: NMEA_parser.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: bignum.c ssl_srv.c pkcs12.c aesni.c cipher.c version_features.c ecdsa.c aes.c oid.c hmac_drbg.c padlock.c x509.c asn1write.c sha512.c threading.c sha256.c ssl_ciphersuites.c pkcs5.c md.c x509_crt.c x509_csr.c certs.c pem.c cipher_wrap.c ssl_ticket.c platform.c entropy.c ssl_cookie.c havege.c sha1.c md4.c dhm.c x509write_crt.c cmac.c ecp.c md_wrap.c version.c pk.c error.c ripemd160.c ssl_cache.c ccm.c md5.c debug.c ecjpake.c des.c ctr_drbg.c pkwrite.c xtea.c memory_buffer_alloc.c timing.c ssl_tls.c camellia.c entropy_poll.c x509_crl.c arc4.c pkparse.c x509_create.c pk_wrap.c ssl_cli.c pkcs11.c x509write_csr.c ecdh.c rsa.c base64.c blowfish.c asn1parse.c ecp_curves.c gcm.c md2.c
  group Drivers/BSP/B-L475E-IOT1
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Application/WiFi
    ../../Src/: es_wifi_io.c wifi.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
software components: CMSIS:CORE 4.3.0
